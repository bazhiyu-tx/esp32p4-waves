## sdkconfig.defaults
```kconfig
CONFIG_LV_DRAW_BUF_ALIGN=128
CONFIG_LV_USE_PPA=y
CONFIG_LV_USE_PPA_IMG=y
# CONFIG_DMA2D_ISR_IRAM_SAFE is not set
CONFIG_LVGL_PORT_ENABLE_PPA=y
```
